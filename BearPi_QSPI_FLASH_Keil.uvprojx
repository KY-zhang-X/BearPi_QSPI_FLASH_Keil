# Keil uVision project BearPi_QSPI_FLASH_Keil.uvprojx, settings and files
target BearPi_W25Q64JV (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BearPi_W25Q64JV
  AfterMake: cmd.exe /C copy "Objects\%L" ".\@L.FLM"
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L431xx
  c include: .\Core\Inc;.\Core\Hardware\W25QXX-QSPI;.\Drivers\STM32L4xx_HAL_Driver\Inc;.\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy;.\Drivers\CMSIS\Device\ST\STM32L4xx\Include;.\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Documentation
    ./Flash/: Abstract.txt
  group Program Functions
    ./Flash/: FlashPrg.c
  group Device Description
    ./Flash/: FlashDev.c
  group Application/User
    ./Core/Src/: gpio.c main.c quadspi.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ./Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ./Core/Src/: system_stm32l4xx.c
  group Hardware
    ./Core/Hardware/W25QXX-QSPI/: w25qxx.c
